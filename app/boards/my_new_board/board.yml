## app/boards/my_new_board/board.yml
```yaml
board:
  name: my_new_board
  full_name: My New Board
  vendor: iomico
  socs:
  # Physical nRF52840 SoC on PCA10056
  - name: nrf52840
```
